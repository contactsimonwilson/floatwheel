# Keil uVision project LCM_Light_Control_IO_WS2812_New.uvprojx, settings and files
target LCM_Light_Control_IO_WS2812_New (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: HK32F030MF4P6 HK_MicroChip
  pack: HKMicroChip.HK32F030xMxx_DFP.1.0.17
  cpu: IRAM(0x20000000,0x800) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LCM_Light_Control_IO_WS2812_New +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HK32F030M, HK32F030MF4P6
  c include: ..\..\Code\App;..\..\Code\Drive;..\..\Code\User;..\..\Library\HK32F030Mxx_Library_V1.1.6\HK32F030M\HK32F030M_Lib\inc;..\..\Library\HK32F030Mxx_Library_V1.1.6\HK32F030M\CMSIS\CM0\Core;..\..\Library\HK32F030Mxx_Library_V1.1.6\HK32F030M\CMSIS\HK32F030M\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group Startup
    ../../Library/HK32F030Mxx_Library_V1.1.6/HK32F030M/CMSIS/HK32F030M/Source/ARM/: KEIL_Startup_hk32f030m.s
  group User
    ../../Code/User/: main.c hk32f030m_it.c
    ../../Library/HK32F030Mxx_Library_V1.1.6/HK32F030M/CMSIS/HK32F030M/Source/: system_hk32f030m.c
  group App
    ../../Code/App/: ws2812.c crc.c vesc_uasrt.c test.c task.c flag_bit.c
  group Drive
    ../../Code/Drive/: led.c time.c spi.c power.c led_pwm.c key.c buzzer.c usart.c adc.c io_ws2812.c iwdg.c
  group Library
    ../../Library/HK32F030Mxx_Library_V1.1.6/HK32F030M/HK32F030M_Lib/src/: hk32f030m_adc.c hk32f030m_gpio.c hk32f030m_iwdg.c hk32f030m_misc.c hk32f030m_rcc.c hk32f030m_spi.c hk32f030m_syscfg.c hk32f030m_tim.c hk32f030m_usart.c
  group Readme
    ../../Readme/: Readme.txt
