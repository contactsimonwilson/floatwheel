# Keil uVision project Mass_Storage.uvprojx, settings and files
target N32L40x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32L406MB Nationstech
  pack: Nationstech.N32L40x_DFP.0.1.0
  cpu: IRAM(0x20000000,0x6000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Mass_Storage
  AfterMake: fromelf --bin --output=.\bin\Mass_Storage.bin .\Objects\Mass_Storage.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32L40X, USE_STDPERIPH_DRIVER,SYSCLK_FREQ=48000000,SYSCLK_SRC=SYSCLK_USE_HSE_PLL
  c misc: --c99
  c include: ..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32l40x_std_periph_driver\inc;..\..\..\..\..\..\middlewares\rt-thread\include;..\..\..\..\..\..\middlewares\rt-thread\components\drivers\include\drivers;..\..\..\..\..\..\middlewares\rt-thread\components\drivers\include\ipc;..\..\..\..\..\..\middlewares\rt-thread\components\drivers\include;..\..\..\..\..\..\middlewares\rt-thread\components\finsh;..\..\DeviceDrivers\gpio\inc;..\..\DeviceDrivers\uart\inc;..\inc;..\..\..\..\..\..\middlewares\rt-thread\components\drivers\cherryusb\core;..\..\..\..\..\..\middlewares\rt-thread\components\drivers\cherryusb\common;..\..\..\..\..\..\middlewares\rt-thread\components\drivers\cherryusb\port\fsdev;..\..\..\..\..\..\middlewares\rt-thread\components\drivers\cherryusb\class\msc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32l40x.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32l40x.c
  group FWLB
    ../../../../../../firmware/n32l40x_std_periph_driver/src/: misc.c n32l40x_exti.c n32l40x_gpio.c n32l40x_rcc.c n32l40x_usart.c n32l40x_flash.c
  group RT_Thread
    ../../../../../../middlewares/rt-thread/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c components.c cpu.c signal.c
  group CORTEX-M4
    ../../../../../../middlewares/rt-thread/libcpu/cortex-m4/: context_rvds.S cpuport.c
  group USER
    ../src/: board.c main.c mass_storage.c n32l40x_it.c
  group Drivers
    ../../../../../../middlewares/rt-thread/components/drivers/misc/: pin.c
    ../../../../../../middlewares/rt-thread/components/drivers/serial/: serial.c
    ../../../../../../middlewares/rt-thread/components/drivers/src/: completion.c
  group Device_Drivers
    ../../DeviceDrivers/gpio/src/: drv_gpio.c
    ../../DeviceDrivers/uart/src/: drv_usart.c
  group USB_Stack
    ../../../../../../middlewares/rt-thread/components/drivers/cherryusb/core/: usbd_core.c
    ../../../../../../middlewares/rt-thread/components/drivers/cherryusb/port/fsdev/: usb_dc_fsdev.c
    ../../../../../../middlewares/rt-thread/components/drivers/cherryusb/class/msc/: usbd_msc.c
  group DOC
    ../: readme.txt
