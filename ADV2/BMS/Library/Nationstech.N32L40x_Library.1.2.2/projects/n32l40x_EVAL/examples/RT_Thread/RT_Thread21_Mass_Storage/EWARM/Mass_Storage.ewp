# IAR project Mass_Storage.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32L406MB Nations N32L406MB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32L40X; USE_STDPERIPH_DRIVER; SYSCLK_FREQ=48000000; SYSCLK_SRC=SYSCLK_USE_HSE_PLL
  ICCARM.CCDiagSuppress: Pe021,Pa084,Pe609
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32l40x_std_periph_driver\inc; ..\..\..\..\..\..\middlewares\rt-thread\include; ..\..\..\..\..\..\middlewares\rt-thread\components\drivers\include\drivers; ..\..\..\..\..\..\middlewares\rt-thread\components\drivers\include\ipc; ..\..\..\..\..\..\middlewares\rt-thread\components\drivers\include; ..\..\DeviceDrivers\gpio\inc; ..\..\DeviceDrivers\uart\inc; ..\inc; ..\..\..\..\..\..\middlewares\rt-thread\components\drivers\cherryusb\core; ..\..\..\..\..\..\middlewares\rt-thread\components\drivers\cherryusb\common; ..\..\..\..\..\..\middlewares\rt-thread\components\drivers\cherryusb\port\fsdev; ..\..\..\..\..\..\middlewares\rt-thread\components\drivers\cherryusb\class\msc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Mass_Storage.hex
  ILINK.IlinkOutputFile: Mass_Storage.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32l40x.c
  group CORTEX-M4
    ../../../../../../middlewares/rt-thread/libcpu/cortex-m4/: context_iar.S cpuport.c
  group Device_Drivers
    ../../DeviceDrivers/gpio/src/: drv_gpio.c
    ../../DeviceDrivers/uart/src/: drv_usart.c
  group DOC
    ../: readme.txt
  group Drivers
    ../../../../../../middlewares/rt-thread/components/drivers/src/: completion.c
    ../../../../../../middlewares/rt-thread/components/drivers/misc/: pin.c
    ../../../../../../middlewares/rt-thread/components/drivers/serial/: serial.c
  group FWLB
    ../../../../../../firmware/n32l40x_std_periph_driver/src/: misc.c n32l40x_exti.c n32l40x_flash.c n32l40x_gpio.c n32l40x_rcc.c n32l40x_usart.c
  group RT-Thread
    ../../../../../../middlewares/rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32l40x_EWARM.s
  group USB_Stack
    ../../../../../../middlewares/rt-thread/components/drivers/cherryusb/port/fsdev/: usb_dc_fsdev.c
    ../../../../../../middlewares/rt-thread/components/drivers/cherryusb/core/: usbd_core.c
    ../../../../../../middlewares/rt-thread/components/drivers/cherryusb/class/msc/: usbd_msc.c
  group USER
    ../src/: board.c main.c mass_storage.c n32l40x_it.c
