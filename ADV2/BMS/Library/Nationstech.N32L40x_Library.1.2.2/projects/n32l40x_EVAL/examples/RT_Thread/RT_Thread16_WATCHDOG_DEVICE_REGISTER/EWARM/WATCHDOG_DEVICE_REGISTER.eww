<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\WATCHDOG_DEVICE_REGISTER.ewp</path>
    </project>
    <batchBuild />
</workspace>
