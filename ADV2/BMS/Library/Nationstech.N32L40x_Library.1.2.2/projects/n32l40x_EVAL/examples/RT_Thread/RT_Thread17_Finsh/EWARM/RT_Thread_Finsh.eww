<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\RT_Thread_Finsh.ewp</path>
    </project>
    <batchBuild />
</workspace>
