<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\UART_DEVICE_REGISTER.ewp</path>
    </project>
    <batchBuild />
</workspace>
