<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\I2C_Ram.ewp</path>
  </project>
  <batchBuild/>
</workspace>
