<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\NVIC_VectorTable_Relocation_Proj.ewp</path>
  </project>
  <batchBuild/>
</workspace>
