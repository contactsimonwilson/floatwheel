# Keil uVision project LoopBack_CAN.uvprojx, settings and files
target N32L40x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32L406MB Nationstech
  pack: Nationstech.N32L40x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x6000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LoopBack_CAN_Project +hex
  AfterMake: fromelf --bin --output=.\bin\LoopBack_CAN_Project.bin .\Objects\LoopBack_CAN_Project.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32L40X, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32l40x_std_periph_driver\inc;..\..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32l40x.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32l40x.c
  group FWLB
    ../../../../../../firmware/n32l40x_std_periph_driver/src/: misc.c n32l40x_can.c n32l40x_gpio.c n32l40x_rcc.c n32l40x_usart.c
  group USER
    ../src/: main.c n32l40x_it.c User_Can_Config.c User_Systick_Config.c
  group DOC
    ../: readme.txt
  group LOG
    ../../../../bsp/src/: log.c
