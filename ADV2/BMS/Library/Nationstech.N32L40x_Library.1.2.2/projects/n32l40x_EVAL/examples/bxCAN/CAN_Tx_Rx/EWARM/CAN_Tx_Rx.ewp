# IAR project CAN_Tx_Rx.ewp, settings and files
configuration N32L40x (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: N32L40X; _DLIB_FILE_DESCRIPTOR; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ../inc; ../../../../../../firmware/CMSIS/core; ../../../../../../firmware/CMSIS/device; ../../../../../../firmware/n32l40x_std_periph_driver/inc; ../../../../bsp/inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: template_project.out
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32l40x.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32l40x_std_periph_driver/src/: misc.c n32l40x_can.c n32l40x_exti.c n32l40x_flash.c n32l40x_gpio.c n32l40x_pwr.c n32l40x_rcc.c n32l40x_usart.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32l40x_EWARM.s
  group USER
    ../src/: main.c n32l40x_it.c User_Can_Config.c User_LED_Config.c User_Systick_Config.c User_Usart_Config.c
