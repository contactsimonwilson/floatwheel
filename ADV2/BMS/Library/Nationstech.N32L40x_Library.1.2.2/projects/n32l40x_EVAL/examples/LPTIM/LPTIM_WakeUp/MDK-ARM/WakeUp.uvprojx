# Keil uVision project WakeUp.uvprojx, settings and files
target N32L40x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32L406MB Nationstech
  pack: Nationstech.N32L40x_DFP.0.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: WakeUp +hex
  AfterMake: fromelf --bin --output=.\bin\WakeUp.bin .\Objects\WakeUp.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: n32l40x, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32l40x_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32l40x.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32l40x.c
  group USER
    ../src/: main.c n32l40x_it.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32l40x_std_periph_driver/src/: n32l40x_rcc.c misc.c n32l40x_exti.c n32l40x_flash.c n32l40x_gpio.c n32l40x_lptim.c n32l40x_pwr.c n32l40x_dbg.c
