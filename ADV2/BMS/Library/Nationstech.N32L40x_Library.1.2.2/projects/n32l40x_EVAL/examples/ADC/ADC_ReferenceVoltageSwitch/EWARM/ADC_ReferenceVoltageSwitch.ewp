# IAR project ADC_ReferenceVoltageSwitch.ewp, settings and files
configuration N32L40x (ARM, debug)
  General.OGChipSelectEditMenu: N32L406MB Nations N32L406MB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32L40X; _DLIB_FILE_DESCRIPTOR; __IAR_ARM; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ../inc; ../../../../../../firmware/CMSIS/core; ../../../../../../firmware/CMSIS/device; ../../../../../../firmware/n32l40x_std_periph_driver/inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ADC_ReferenceVoltageSwitch.bin
  ILINK.IlinkOutputFile: ADC_ReferenceVoltageSwitch.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32l40x.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32l40x_std_periph_driver/src/: misc.c n32l40x_adc.c n32l40x_dma.c n32l40x_gpio.c n32l40x_rcc.c n32l40x_tim.c n32l40x_usart.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32l40x_EWARM.s
  group USER
    ../src/: main.c n32l40x_it.c
