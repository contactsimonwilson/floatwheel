# IAR project SmartCard.ewp, settings and files
configuration N32L40x (ARM, debug)
  General.OGChipSelectEditMenu: N32L406MB Nations N32L406MB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32L40X; _DLIB_FILE_DESCRIPTOR; USE_STDPERIPH_DRIVER; USE_FULL_ASSERT
  ICCARM.CCDiagSuppress: pa084
  ICCARM.CCIncludePath2: ../inc; ../../../../../../firmware/CMSIS/core; ../../../../../../firmware/CMSIS/device; ../../../../../../firmware/n32l40x_std_periph_driver/inc; ..\..\..\..\bsp\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SmartCard.bin
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32l40x.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32l40x_std_periph_driver/src/: misc.c n32l40x_dma.c n32l40x_gpio.c n32l40x_rcc.c n32l40x_usart.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32l40x_EWARM.s
  group USER
    ../src/: delay.c main.c n32l40x_it.c smartcard.c
    ../../../../bsp/src/: log.c
